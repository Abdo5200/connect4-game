# Keil uVision project Lab6.uvproj, settings and files
target Lab6 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab6
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s BranchingFunctionsDelays.c Connect4.c game.c GPIO.c LED.c Nokia5110.c ADC.c PWM.c GPTM_Driver.c oled_i2c.c gg.c
    ../driverlib/: cpu.c i2c.c interrupt.c
  group Object code
    ./: texas.o
